Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-10-10T12:10:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 10 12:10:38 2024 * Host: DESKTOP-BQGE6H4 * Database: C:\Users\Avocado\AppData\Local\Temp\8f93c90a-c7b8-4513-8acb-ad717d5238bc\ed0d7b1e-0bef-4dc1-b1c8-d9fb326e8f6a\ifc * Database version: 5507 * Database creation date: Thu Oct 10 12:10:37 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 10 12:10:38 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 10 12:10:38 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 50968101 Washbasin faucet, 50968101(2020):50968101 Washbasin faucet:487847
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Construction - Type: 0
Type - Dimensions - NominalDepth: 194 mm; NominalHeight: 109.4 mm; NominalWidth: 60 mm
Type - General - Author: BIMStone; BIMObjectName: 50968101; ManufacturerName: HANSA; ManufacturerURL: http://www.hansa.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 20/08/2024
Type - Green Building Properties - Approval KIWA: K100538/01; EAN Number: 4015474171725; EN Standard: EN 817; ETIM Class Number: EC011375 Water tap; Sales Package dimensions (LxWxH): 260 x 110 x 110; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.hansa.com/doc/asbestos; URL Declaration of Conformity: http://static.hansa.com/DoC/50968101; URL Declaration Of Performance (DOP): http://static.hansa.com/doc/DoP; URL Declaration of SCIP: http://static.hansa.com/doc/SCIP; URL EcoLabel Declaration: http://static.hansa.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.hansa.com/doc/packaging; URL KIWA: http://static.hansa.com/Kiwa/50968101; URL REACH: http://static.hansa.com/doc/reach; URL UWL: http://static.hansa.com/UWL/50968101
Type - Identity Data - 2D/3D/BIM Files URL: http://static.hansa.com/bim/50968101; 3D View: https://static.hansa.com/3D/50968101; Catalog Drawing URL: http://static.hansa.com/catdrw/50968101; Category B2B: Public & Semi-public;Industry; Color variants: 5096810133; Dimension Drawing URL: http://static.hansa.com/dimdrw/50968101; FDV Document URL: http://www.hansa.com/datasheet/50968101/en/fdv; Flow Drawing URL: http://static.hansa.com/flowchart/50968101; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.hansa.com/manual/50968101; Interactive AR View URL: https://static.hansa.com/AR/50968101; Manufacturer: HANSA; Market: Austria;Belgium;Czech Republic;Germany;Spain;France;International;Italy;Netherlands;Slovakia; Mobile Product Information URL: http://mpi.hansa.com/50968101; Model: 50968101 Washbasin faucet; Name_en: 50968101 Washbasin faucet; OmniClass Number: 23.45.55.00; Product Code: 50968101; Product Family: HANSANOVA Style; Product Image URL: http://static.hansa.com/image/50968101; Product URL: http://static.hansa.com/50968101; Spare-Part Information URL: http://static.hansa.com/sp/50968101; Technical DataSheet URL: http://www.hansa.com/datasheet/50968101/en; Type Name: 50968101 Washbasin faucet; Usage Group: Offices;Airports;SportsStadiums;Hotels;IndustrialBuildings; Warranty Information URL: http://warranty.hansa.com
Type - Materials and Finishes - FaucetMainMaterial: Chrome
Type - Mechanical - Advanced Features: Flexible length / can be shortened;Inner body made of DZR brass; Aerator: Hidden aerator; Backflow Prevention EN1717: AA; Connection: One inlet for cold or premixed water; Connection Size: G1/2; Flow Rate At 300kPa: 0.00353147 m3/s; Installation Type: Wall mounted; Lever Handle: Single operating lever/handle; Max. Hot Water Supply: 80 kg/K/s3; Mechanical Parts: Ceramic head part for flow control; Pressure Loss With Flow 01ls: 300000 Pa; Spout Projection: 126-186 mm; Spout Type: Fixed spout; Surface treatment: Chrome; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: HANSA; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 50968101(2020); Features: Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 50968101; Name: 50968101 Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 60x195x110 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.hansa.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 50968101 Washbasin faucet; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 50968101; Manufacturer: HANSA
Pset_ProductRequirements - Name: 50968101 Washbasin faucet; Category: Plumbing Fixtures
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.039409 m2; Volume: 0.00127258 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 50968101(2020): 50968101 Washbasin faucet; Family and Type: 50968101(2020): 50968101 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 50968101(2020): 50968101 Washbasin faucet; Type Id: 50968101(2020): 50968101 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
